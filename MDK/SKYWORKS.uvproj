# Keil uVision project SKYWORKS.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SKYWORKS +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Src;..\Src\algorithm;..\Src\driver;..\Src\others;D:\stm32lib\stm32f10x\CMSIS\CM3;D:\stm32lib\stm32f10x\STM32F10x_StdPeriph_Driver\inc;D:\stm32lib\stm32f10x\CMSIS\CM3\DeviceSupport\ST\STM32F10x;D:\stm32lib\STM32_CPAL_Driver\inc;D:\stm32lib\STM32_CPAL_Driver\devices\stm32f10x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Src/: main.c stm32f10x_it.c global.c
  group algorithm
    ../Src/algorithm/: AHRS.c Control.c filter.c MadgwickAHRS.c my_control.c
  group driver
    ../Src/driver/: my_i2c.c my_sensor.c my_timer.c my_usart.c UARTtools.c
  group others
    ../Src/others/: DataReceiver.c my_misc.c nvic.c
  group CMSIS
    D:/stm32lib/stm32f10x/CMSIS/CM3/CoreSupport/: core_cm3.c
    D:/stm32lib/stm32f10x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    D:/stm32lib/stm32f10x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_dma.c
  group StartUp
    ./: startup_stm32f10x_md.s
  group CPAL
    D:/stm32lib/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback_template.c
    D:/stm32lib/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
